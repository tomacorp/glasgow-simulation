*** auto-generated by jitpcb ***
.title jitpcb-generated-spice

* begin model Package_DFN_QFN:UDFN-6-1EP_2.1x2.1mm_P0.8mm:
*   begin metadata:
*     description: 7-pin WSON EP package
*     manufacturer: UNKNOWN
*     mpn: TLV75533PDRVR
*   end metadata
*   begin pin-mapping:
*     OUT: OUT
*     NC1: NC1
*     GND: GND
*     EN: EN
*     NC2: NC2
*     IN: IN
*   end pin-mapping
.subckt TLV75533PDRVR OUT NC1 GND EN NC2 IN
  MSW  IN  VGEN VSW VSW MOSEN
  MCL VSW VCL VCL VCL MOSCL
  MREG VCL  GND   OUT   OUT  MOSREG
  M4 VNEN  EN  VUVLO VUVLO MOSLOGN
  M7 VUVLO  IN   GND   GND  MOSUVLO
  M6 VFEN VNEN  GND   GND  MOSLOGN
  M5 VFEN VNEN  IN   IN  MOSLOGP
  D1  OUT   IN  SUBSTRATE
  C2 VCL  GND  1000p
  C3 VNEN  GND  100f
  C5 VGEN  GND  20p
  C6 VUVLO  GND  100f
  C7 VSW  GND  100p
  R2  IN  VNEN 1MEG
  R3 VFEN VGEN 10MEG
  CCL VCL  GND  1n
  .model MOSREG  NMOS LEVEL=1 RD=1e-3 RS=1e-3 VTO=-3.3   KP=1000
  .model MOSCL   NMOS LEVEL=1 RD=1e-3 RS=1e-3 VTO=-75e-3 KP=256
  .model MOSEN   NMOS LEVEL=1 RD=1e-3 RS=1e-3 VTO=25e-3  KP=1000
  .model MOSLOGN NMOS LEVEL=1 RD=10   RS=10   VTO=0.8    KP=1000u
  .model MOSLOGP PMOS LEVEL=1 RD=10   RS=10   VTO=-0.3   KP=200u
  .model MOSUVLO NMOS LEVEL=1 RD=10   RS=10   VTO=1.3    KP=500u
  .model SUBSTRATE D RS=0.01 N=1.5
.ends
* end model
* begin model Package_DFN_QFN:UDFN-6-1EP_2.1x2.1mm_P0.8mm:
*   begin metadata:
*     description: 7-pin WSON EP package
*     manufacturer: UNKNOWN
*     mpn: TLV73312PDRVR
*   end metadata
*   begin pin-mapping:
*     OUT: OUT
*     NC1: NC1
*     GND: GND
*     EN: EN
*     NC2: NC2
*     IN: IN
*   end pin-mapping
.subckt TLV73312PDRVR OUT NC1 GND EN NC2 IN
  M1  IN  N001 VSW VSW mosen
  M2 VSW VCL VCL VCL moscl
  M3 VCL  GND   OUT   OUT  mosreg
  C2 N003  GND  100pF
  M4 VNEN  EN   GND   GND  moslogn
  C3 VNEN  GND  100fF
  C5 N001  GND  1.5pF
  R2  IN  VNEN 1Meg
  M7 VUVLO  IN   GND   GND  mosuvlo
  C6 VUVLO  GND  100fF
  C7 N002  GND  100pF
  D1  OUT   IN  substrate
  R5  IN  VUVLO 1Meg
  M11 VNUVLO VUVLO  IN   IN  moslogp
  M12 VNUVLO VUVLO  GND   GND  moslogn
  M5 VFEN VNEN  IN   IN  moslogp
  M6 VFEN VNEN  GND   GND  moslogn
  M9 N005 VNUVLO  GND   GND  moslogn
  M10 N004 VFEN N005 N005 moslogn
  M13 N004 VNUVLO  IN   IN  moslogp
  M14 N004 VFEN  IN   IN  moslogp
  M15 VFEN N001 N001 N001 softstart
  C8 VNUVLO  GND  2pF
  C9 VFEN  GND  2pF
  C10 N004  GND  100pF
  D2  EN   IN  inpprotect
  D3  GND   EN  inpprotect
  D4  GND   OUT  outprotect
  R3  IN   EN  10Meg
  R6 VENS  EN  50
  M16 N003 N004  GND   GND  mosacti
  R7 VCL N003 240
  M17 N002 N004  GND   GND  mosacti
  R8 VSW N002 240
  .model mosreg NMOS LEVEL=1 RD=200m RS=10m VTO=-1.2 KP=1000
  .model moscl NMOS LEVEL=1 RD=200m RS=10m VTO=-75m KP=180
  .model mosen NMOS LEVEL=1 RD=200m RS=10m VTO=25m KP=1000
  .model moslogn NMOS LEVEL=1 RD=40 RS=40 VTO=0.8 KP=100u
  .model moslogp PMOS LEVEL=1 RD=40 RS=40 VTO=-0.3 KP=20u
  .model mosuvlo NMOS LEVEL=1 RD=10 RS=10 VTO=1.3 KP=50u
  .model substrate D RS=.01 N=1.5
  .model inpprotect D RS=1 N=1 IS=1e-6
  .model outprotect D RS=0.1 N=1 BV=3.6 IBV=10u
  .model softstart NMOS LEVEL=1 RD=10 RS=10 VTO=-75m KP=2u
  .model mosacto NMOS LEVEL=1 RD=119 RS=1 VTO=25m KP=100
  .model mosacti NMOS LEVEL=1 RD=4 RS=1 VTO=25m KP=1
.ends
* end model
* begin model Connector_USB:USB_Micro-B_Molex_47346-0001:
*   begin metadata:
*     description: Micro USB B receptable with flange, bottom-mount, SMD, right-angle (http://www.molex.com/pdm_docs/sd/473460001_sd.pdf
*     manufacturer: UNKNOWN
*     mpn: UNKNOWN
*   end metadata
*   begin pin-mapping:
*     p[1]: p1
*     p[2]: p2
*     p[3]: p3
*     p[4]: p4
*     p[5]: p5
*     p[6]: p6
*   end pin-mapping
.subckt Connector_USB:USB_Micro_B_Molex_47346_0001 p1 p2 p3 p4 p5 p6
  V1  p1   p5  EXP(0 5 200u 200u 20 20)
  RPU  p3   p1  50
  RDK  p2   p5  50
  RRSH  p5   p6  1
  RNC1  p4   p5  100MEG
.ends
* end model
* begin model Package_TO_SOT_SMD:SOT-23-6:
*   begin metadata:
*     description: 6-pin SOT-23 package
*     manufacturer: UNKNOWN
*     mpn: LM3880
*   end metadata
*   begin pin-mapping:
*     VCC: VCC
*     GND: GND
*     EN: EN
*     FLAG1: FLAG1
*     FLAG2: FLAG2
*     FLAG3: FLAG3
*   end pin-mapping
.subckt LM3880 VCC GND EN FLAG1 FLAG2 FLAG3
  M1 VNI  EN  VSDP VSDP MDIFF
  M2 VNP VZREF VSDP VSDP MDIFF
  D1  GND  VZREF DZREF
  M3 VNI VNI  VCC   VCC  MPMIR
  M4 VNP VNP  VCC   VCC  MPMIR
  M5 ENA VNI  VCC   VCC  MPGAIN
  M6 ENB VNP  VCC   VCC  MPGAIN
  M7 VSDP  GND   GND   GND  MDISRC
  M8 ENA VSG VSG VSG MDISRC
  M9 ENB VSG VSG VSG MDISRC
  M10  VCC  VZREF VZREF VZREF MDISRC
  R1  VCC   EN  24.3K
  M11 VSG  GND   GND   GND  MDIGAIN
  M12 VCMP ENB  VCC   VCC  MOSLOGP
  M13 VCMP ENB  GND   GND  MOSLOGN
  M14  VCC   EN   EN   EN  MPPU
  C1  EN   GND  7pF
  C2 VZREF  GND  4pF
  C3 ENB  GND  1.3pF
  C4 VNP  GND  2.5pF
  C5 VNI  GND  2.5pF
  C6 ENA  GND  1.3pF
  M15 VCMP  GND  VRGO VRGO MVREG
  C7 VCMP  GND  7pF
  C8 VRGO  GND  7pF
  C9 VRAMP N003 5nF
  D2 VRGI VRAMP DRAMP
  M16 VDRMP VCMP VCMP VCMP MIRAMP
  M17 VRGO VRGI VRGI VRGI MIRAMP
  D3 VRAMP VDRMP DRAMP
  C10 VDRMP VCMP 7pF
  C11 VRGI VRGO 7pF
  M18 VNIA VRAMP VSDPA VSDPA MDIFF
  M19 VNPA VZREFA VSDPA VSDPA MDIFF
  D4  GND  VZREFA DZREFA
  M20 VNIA VNIA  VCC   VCC  MPMIR
  M21 VNPA VNPA  VCC   VCC  MPMIR
  M22 ENAA VNPA  VCC   VCC  MPGAIN
  M23 ENBA VNIA  VCC   VCC  MPGAIN
  M24 VSDPA  GND   GND   GND  MDISRC
  M25 ENAA VSGA VSGA VSGA MDISRC
  M26 ENBA VSGA VSGA VSGA MDISRC
  M27  VCC  VZREFA VZREFA VZREFA MDISRC
  M28 VSGA  GND   GND   GND  MDIGAIN
  M29  FLAG3  ENAA  VCC   VCC  MOSFLAGP
  M30  FLAG3  ENAA  GND   GND  MOSFLAGN
  C13 VZREFA  GND  4pF
  C14 ENAA  GND  1.3pF
  C15 VNIA  GND  2.5pF
  C16 VNPA  GND  2.5pF
  C17 ENBA  GND  1.3pF
  C18  FLAG3   GND  7pF
  M31 VNIB VRAMP VSDPB VSDPB MDIFF
  M32 VNPB VZREFB VSDPB VSDPB MDIFF
  D5  GND  VZREFB DZREFB
  M33 VNIB VNIB  VCC   VCC  MPMIR
  M34 VNPB VNPB  VCC   VCC  MPMIR
  M35 ENBB VNPB  VCC   VCC  MPGAIN
  M36 ENAB VNIB  VCC   VCC  MPGAIN
  M37 VSDPB  GND   GND   GND  MDISRC
  M38 ENBB VSGB VSGB VSGB MDISRC
  M39 ENAB VSGB VSGB VSGB MDISRC
  M40  VCC  VZREFB VZREFB VZREFB MDISRC
  M41 VSGB  GND   GND   GND  MDIGAIN
  M42  FLAG2  ENBB  VCC   VCC  MOSFLAGP
  M43  FLAG2  ENBB  GND   GND  MOSFLAGN
  C12 VZREFB  GND  4pF
  C19 ENBB  GND  1.3pF
  C20 VNIB  GND  2.5pF
  C21 VNPB  GND  2.5pF
  C22 ENAB  GND  1.3pF
  C23  FLAG2   GND  7pF
  M44 VNIC VRAMP VSDPC VSDPC MDIFF
  M45 VNPC VZREFC VSDPC VSDPC MDIFF
  D6  GND  VZREFC DZREFC
  M46 VNIC VNIC  VCC   VCC  MPMIR
  M47 VNPC VNPC  VCC   VCC  MPMIR
  M48 ENAC VNPC  VCC   VCC  MPGAIN
  M49 N001 VNIC  VCC   VCC  MPGAIN
  M50 VSDPC  GND   GND   GND  MDISRC
  M51 ENAC VSGC VSGC VSGC MDISRC
  M52 N001 VSGC VSGC VSGC MDISRC
  M53  VCC  VZREFC VZREFC VZREFC MDISRC
  M54 VSGC  GND   GND   GND  MDIGAIN
  M55  FLAG1  ENAC  VCC   VCC  MOSFLAGP
  M56  FLAG1  ENAC  GND   GND  MOSFLAGN
  C24 VZREFC  GND  4pF
  C25 ENAC  GND  1.3pF
  C26 VNIC  GND  2.5pF
  C27 VNPC  GND  2.5pF
  C28 N001  GND  1.3pF
  C29  FLAG1   GND  7pF
  D7  GND   EN  DESD
  D8  EN   VCC  DESD
  D9 N003 VRAMP DZRAMP
  M57  GND   GND  N003 N003 MPVN
  C30 N003  GND  200pF
  M59  VCC  N003 N003 N003 MDISRC
  .model MDIFF NMOS LEVEL=1 RD=10 RS=10 VTO=-0.35 KP=100u
  .model MDISRC NMOS LEVEL=1 RD=10 RS=10 VTO=-0.35 KP=65.3u
  .model MPMIR PMOS LEVEL=1 RD=10 RS=10 VTO=.35 KP=40u
  .model MPGAIN PMOS LEVEL=1 RD=10 RS=10 VTO=0.15 KP=110u
  .model MDIGAIN NMOS LEVEL=1 RD=10 RS=10 VTO=-0.35 KP=200u
  .model MPPU NMOS LEVEL=1 RD=10 RS=10 VTO=-0.8 KP=21.875u
  .model MOSLOGN NMOS LEVEL=1 RD=10 RS=10 VTO=0.8 KP=100u
  .model MOSLOGP PMOS LEVEL=1 RD=10 RS=10 VTO=-0.3 KP=20u
  .model MOSFLAGN NMOS LEVEL=1 RD=1 RS=1 VTO=0.8 KP=2.2m
  .model MOSFLAGP PMOS LEVEL=1 RD=1 RS=1 VTO=-0.3 KP=440u
  .model DZREF D RS=0.1 N=1 BV=1.25 IBV=4u
  .model DZREFA D RS=0.1 N=1 BV=1.4 IBV=4u
  .model DZREFB D RS=0.1 N=1 BV=1.1 IBV=4u
  .model DZREFC D RS=0.1 N=1 BV=0.8 IBV=4u
  .model DZRAMP D RS=0.1 N=1 BV=1.1 IBV=4u
  .model DESD D RS=0.1 N=1 IS=1e-8
  .model MVREG NMOS LEVEL=1 RD=10 RS=10 VTO=-2.2 KP=100u
  .model MPVN PMOS LEVEL=1 RD=10 RS=10 VTO=-0.5 KP=10m
  .model MIRAMP NMOS LEVEL=1 RD=10 RS=10 VTO=-0.5 KP=0.8u
  .model DRAMP D RS=1000 N=1 IS=1e-12
  .model QRAMP NPN BF=50 RE=1 RC=1 RB=10 CJE=10P
.ends
* end model
* begin model Capacitor_SMD:C_0402_1005Metric:
*   begin metadata:
*     description: Capacitor 0.1uF SMD CHIP 0402(English) 25V X5R 10% 0.5mm thick
*     manufacturer: UNKNOWN
*     mpn: UNKNOWN
*   end metadata
*   begin pin-mapping:
*     p[1]: p1
*     p[2]: p2
*   end pin-mapping
.subckt Capacitor_SMD:C_0402_1005Metric p1 p2
  C13   p1   p2   1.0e-07
.ends
* end model
* begin model gen-res-cmp$26:
*   begin metadata:
*     description:
*     manufacturer: UNKNOWN
*     mpn: UNKNOWN
*   end metadata
*   begin pin-mapping:
*     p[1]: p1
*     p[2]: p2
*   end pin-mapping
.subckt gen_res_cmp_26 p1 p2
  R217175   p1   p2   24300.0
.ends
* end model
* begin model Capacitor_SMD:C_0402_1005Metric:
*   begin metadata:
*     description: Capacitor 0.1uF SMD CHIP 0402(English) 25V X5R 10% 0.5mm thick
*     manufacturer: UNKNOWN
*     mpn: UNKNOWN
*   end metadata
*   begin pin-mapping:
*     p[1]: p1
*     p[2]: p2
*   end pin-mapping
.subckt Capacitor_SMD:C_0402_1005Metric p1 p2
  C8   p1   p2   1.0e-07
.ends
* end model
* begin model gen-res-cmp$28:
*   begin metadata:
*     description:
*     manufacturer: UNKNOWN
*     mpn: UNKNOWN
*   end metadata
*   begin pin-mapping:
*     p[1]: p1
*     p[2]: p2
*   end pin-mapping
.subckt gen_res_cmp_28 p1 p2
  R217176   p1   p2   10000.0
.ends
* end model
* begin model Capacitor_SMD:C_0402_1005Metric:
*   begin metadata:
*     description: Capacitor 0.1uF SMD CHIP 0402(English) 25V X5R 10% 0.5mm thick
*     manufacturer: UNKNOWN
*     mpn: UNKNOWN
*   end metadata
*   begin pin-mapping:
*     p[1]: p1
*     p[2]: p2
*   end pin-mapping
.subckt Capacitor_SMD:C_0402_1005Metric p1 p2
  C26   p1   p2   4.7e-06
.ends
* end model
* begin model gen-res-cmp$29:
*   begin metadata:
*     description:
*     manufacturer: UNKNOWN
*     mpn: UNKNOWN
*   end metadata
*   begin pin-mapping:
*     p[1]: p1
*     p[2]: p2
*   end pin-mapping
.subckt gen_res_cmp_29 p1 p2
  R217177   p1   p2   100000.0
.ends
* end model
* begin model Capacitor_SMD:C_0402_1005Metric:
*   begin metadata:
*     description: Capacitor 0.1uF SMD CHIP 0402(English) 25V X5R 10% 0.5mm thick
*     manufacturer: UNKNOWN
*     mpn: UNKNOWN
*   end metadata
*   begin pin-mapping:
*     p[1]: p1
*     p[2]: p2
*   end pin-mapping
.subckt Capacitor_SMD:C_0402_1005Metric p1 p2
  C28   p1   p2   4.7e-06
.ends
* end model
* begin model Package_BGA:BGA-121_9.0x9.0mm_Layout11x11_P0.8mm_Ball0.4mm_Pad0.35mm_NSMD:
*   begin metadata:
*     description: 121-ball, 0.8mm BGA (based on http://www.latticesemi.com/view_document?document_id=213
*     manufacturer: UNKNOWN
*     mpn: ICE40HX8K-BG121
*   end metadata
*   begin pin-mapping:
*     GND: GND
*     VCC: VCC
*     CDONE: CDONE
*     IOB-56: IOB_56
*     IOB-57: IOB_57
*     IOB-61: IOB_61
*     IOB-63: IOB_63
*     IOB-64: IOB_64
*     IOB-71: IOB_71
*     IOB-72: IOB_72
*     IOB-73: IOB_73
*     IOB-78: IOB_78
*     IOB-79: IOB_79
*     IOB-86: IOB_86
*     IOB-87: IOB_87
*     IOB-89: IOB_89
*     IOB-91: IOB_91
*     IOB-94: IOB_94
*     IOL-2A: IOL_2A
*     IOL-2B: IOL_2B
*     IOL-4A: IOL_4A
*     IOL-4B: IOL_4B
*     IOL-5A: IOL_5A
*     IOL-5B: IOL_5B
*     IOL-8A: IOL_8A
*     IOL-8B: IOL_8B
*     IOL-9A: IOL_9A
*     IOL-9B: IOL_9B
*     GNDPLL0: GNDPLL0
*     GNDPLL1: GNDPLL1
*     IOL-10A: IOL_10A
*     IOL-10B: IOL_10B
*     IOL-12A: IOL_12A
*     IOL-12B: IOL_12B
*     IOL-13A: IOL_13A
*     IOL-14B: IOL_14B
*     IOL-17A: IOL_17A
*     IOL-17B: IOL_17B
*     IOL-18A: IOL_18A
*     IOL-18B: IOL_18B
*     IOL-23A: IOL_23A
*     IOL-23B: IOL_23B
*     IOL-25A: IOL_25A
*     IOL-25B: IOL_25B
*     IOR-114: IOR_114
*     IOR-115: IOR_115
*     IOR-116: IOR_116
*     IOR-117: IOR_117
*     IOR-118: IOR_118
*     IOR-119: IOR_119
*     IOR-120: IOR_120
*     IOR-128: IOR_128
*     IOR-129: IOR_129
*     IOR-136: IOR_136
*     IOR-137: IOR_137
*     IOR-144: IOR_144
*     IOR-146: IOR_146
*     IOR-147: IOR_147
*     IOR-148: IOR_148
*     IOR-152: IOR_152
*     IOR-154: IOR_154
*     IOR-160: IOR_160
*     IOR-161: IOR_161
*     IOT-168: IOT_168
*     IOT-170: IOT_170
*     IOT-172: IOT_172
*     IOT-174: IOT_174
*     IOT-177: IOT_177
*     IOT-178: IOT_178
*     IOT-179: IOT_179
*     IOT-181: IOT_181
*     IOT-190: IOT_190
*     IOT-191: IOT_191
*     IOT-192: IOT_192
*     IOT-206: IOT_206
*     IOT-207: IOT_207
*     IOT-208: IOT_208
*     IOT-211: IOT_211
*     IOT-212: IOT_212
*     IOT-219: IOT_219
*     IOT-221: IOT_221
*     IOT-222: IOT_222
*     IOT-223: IOT_223
*     IOT-225: IOT_225
*     VCC-SPI: VCC_SPI
*     VCCIO-0: VCCIO_0
*     VCCIO-1: VCCIO_1
*     VCCIO-2: VCCIO_2
*     VCCIO-3: VCCIO_3
*     VCCPLL0: VCCPLL0
*     VCCPLL1: VCCPLL1
*     VPP-2V5: VPP_2V5
*     nCRESET: nCRESET
*     VPP-FAST: VPP_FAST
*     IOB-108-SS: IOB_108_SS
*     IOB-105-SDO: IOB_105_SDO
*     IOB-106-SDI: IOB_106_SDI
*     IOB-107-SCK: IOB_107_SCK
*     IOB-81-GBIN5: IOB_81_GBIN5
*     IOB-82-GBIN4: IOB_82_GBIN4
*     IOL-13B-GBIN7: IOL_13B_GBIN7
*     IOL-14A-GBIN6: IOL_14A_GBIN6
*     IOR-140-GBIN3: IOR_140_GBIN3
*     IOR-141-GBIN2: IOR_141_GBIN2
*     IOT-197-GBIN1: IOT_197_GBIN1
*     IOT-198-GBIN0: IOT_198_GBIN0
*     IOB-103-CBSEL0: IOB_103_CBSEL0
*     IOB-104-CBSEL1: IOB_104_CBSEL1
*   end pin-mapping
.subckt ICE40HX8K_BG121 GND VCC CDONE IOB_56 IOB_57 IOB_61 IOB_63 IOB_64 IOB_71 IOB_72 IOB_73 IOB_78 IOB_79 IOB_86 IOB_87 IOB_89 IOB_91 IOB_94 IOL_2A IOL_2B IOL_4A IOL_4B IOL_5A IOL_5B IOL_8A IOL_8B IOL_9A IOL_9B GNDPLL0 GNDPLL1 IOL_10A IOL_10B IOL_12A IOL_12B IOL_13A IOL_14B IOL_17A IOL_17B IOL_18A IOL_18B IOL_23A IOL_23B IOL_25A IOL_25B IOR_114 IOR_115 IOR_116 IOR_117 IOR_118 IOR_119 IOR_120 IOR_128 IOR_129 IOR_136 IOR_137 IOR_144 IOR_146 IOR_147 IOR_148 IOR_152 IOR_154 IOR_160 IOR_161 IOT_168 IOT_170 IOT_172 IOT_174 IOT_177 IOT_178 IOT_179 IOT_181 IOT_190 IOT_191 IOT_192 IOT_206 IOT_207 IOT_208 IOT_211 IOT_212 IOT_219 IOT_221 IOT_222 IOT_223 IOT_225 VCC_SPI VCCIO_0 VCCIO_1 VCCIO_2 VCCIO_3 VCCPLL0 VCCPLL1 VPP_2V5 nCRESET VPP_FAST IOB_108_SS IOB_105_SDO IOB_106_SDI IOB_107_SCK IOB_81_GBIN5 IOB_82_GBIN4 IOL_13B_GBIN7 IOL_14A_GBIN6 IOR_140_GBIN3 IOR_141_GBIN2 IOT_197_GBIN1 IOT_198_GBIN0 IOB_103_CBSEL0 IOB_104_CBSEL1
  RVCC  VCC   GND  53.8
  RD6  VCCIO_0   GND  943K
  RF8  VCCIO_1   GND  943K
  RH6  VCCIO_2   GND  943K
  RE4  VCCIO_3   GND  943K
  RC6  VCCPLL1   GND  2.4MEG
  RJ6  VCCPLL0   GND  2.4MEG
  RL11  VCC_SPI   GND  943K
  * PKTEND
  RL1  VCCIO_2   IOB_56  61K
  CL1  IOB_56   GND  6.1p
  * END PKTEND
  RLG9  IOR_128   VCCIO_1  60K
  CLG9  IOR_128   GND  6p
.ends
* end model
* begin model Package_TO_SOT_SMD:SOT-23-6:
*   begin metadata:
*     description: 6-pin SOT-23 package
*     manufacturer: UNKNOWN
*     mpn: TPD3S014DBVR
*   end metadata
*   begin pin-mapping:
*     EN: EN
*     GND: GND
*     IN: IN
*     OUT: OUT
*     D1: D1
*     D2: D2
*   end pin-mapping
.subckt TPD3S014DBVR EN GND IN OUT D1 D2
  RON  IN   OUT  0.097
  RDK  OUT   GND  76K
  DA  D1   OUT  DESD
  DB  GND   D1  DESD
  DC  D2   OUT  DESD
  DD  GND   D2  DESD
  RPDA  D1   OUT  10MEG
  RPDC  D2   OUT  10MEG
  DZENER  GND   OUT  D_ZENER
  DENU  EN   IN  DESD
  DEND  GND   EN  DESD
  RRPDENU  IN   EN  100MEG
  .model DESD D RS=1 N=1.5
  .model D_ZENER D RS=1 N=1.5 BV=6 IBV=1m
.ends
* end model
X216807 VUSB USB_N USB_P USB_NC 0 SHLD Connector_USB:USB_Micro_B_Molex_47346_0001 ; J1
X216808 SHLD 0 Capacitor_SMD:C_0402_1005Metric ; C13
X216809 VUSB 0 Capacitor_SMD:C_0402_1005Metric ; C8
X216810 P5V 0 Capacitor_SMD:C_0402_1005Metric ; C26
X216811 P3R3V 0 Capacitor_SMD:C_0402_1005Metric ; C28
X216812 VUSB 0 VUSB P5V USB_N USB_P TPD3S014DBVR ; U15
X216813 P3R3V P3R3V 0 P3V3EN P5V P5V TLV75533PDRVR ; U8
X216814 P5V 0 Capacitor_SMD:C_0402_1005Metric ; C86
X216815 P1R2V 0 Capacitor_SMD:C_0402_1005Metric ; C27
X216816 P1R2V P1R2V 0 P1V2EN P5V P5V TLV73312PDRVR ; U36
X216817 P5V 0 PGOOD P1V2EN P3V3EN 217072 LM3880 ; U7
X216818 P5V PGOOD gen_res_cmp_26 ; R5
X216819 PGOOD 0 gen_res_cmp_28 ; R6
X216820 P5V P3V3EN gen_res_cmp_29 ; R7
X216821 P5V P1V2EN gen_res_cmp_29 ; R8
X216822 0 P1R2V 217073 217074 217075 217076 217077 217078 217079 217080 217081 217082 217083 217084 217085 217086 217087 217088 217089 217090 217091 217092 217093 217094 217095 217096 217097 217098 217099 217100 217101 217102 217103 217104 217105 217106 217107 217108 217109 217110 217111 217112 217113 217114 217115 217116 217117 217118 217119 217120 217121 217122 217123 217124 217125 217126 217127 217128 217129 217130 217131 217132 217133 217134 217135 217136 217137 217138 217139 217140 217141 217142 217143 217144 217145 217146 217147 217148 217149 217150 217151 217152 217153 217154 217155 P3R3V P3R3V P3R3V P3R3V 217156 217157 217158 217159 217160 217161 217162 217163 217164 217165 217166 217167 217168 217169 217170 217171 217172 217173 217174 ICE40HX8K_BG121 ; U30

.options savecurrents
.save all
.op
.end
