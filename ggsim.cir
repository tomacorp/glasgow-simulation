*** auto-generated by jitpcb ***
.title jitpcb-generated-spice

* begin model Package_TO_SOT_SMD:SOT-23-6:
*   begin metadata:
*     description: 6-pin SOT-23 package
*     manufacturer: UNKNOWN
*     mpn: TPD3S014DBVR
*   end metadata
*   begin pin-mapping:
*     EN: EN
*     GND: GND
*     IN: IN
*     OUT: OUT
*     D1: D1
*     D2: D2
*   end pin-mapping
.subckt TPD3S014DBVR EN GND IN OUT D1 D2
  RON  IN   OUT  0.097
  RDK  OUT   GND  76K
  DA  D1   OUT  DESD
  DB  GND   D1  DESD
  DC  D2   OUT  DESD
  DD  GND   D2  DESD
  RPDA  D1   OUT  10MEG
  RPDC  D2   OUT  10MEG
  DZENER  GND   OUT  D_ZENER
  DENU  EN   IN  DESD
  DEND  GND   EN  DESD
  RRPDENU  IN   EN  100MEG
  .model DESD D RS=1 N=1.5
  .model D_ZENER D RS=1 N=1.5 BV=6 IBV=1m
.ends
* end model
* begin model Package_DFN_QFN:UDFN-6-1EP_2.1x2.1mm_P0.8mm:
*   begin metadata:
*     description: 7-pin WSON EP package
*     manufacturer: UNKNOWN
*     mpn: TLV75533PDRVR
*   end metadata
*   begin pin-mapping:
*     OUT: OUT
*     NC1: NC1
*     GND: GND
*     EN: EN
*     NC2: NC2
*     IN: IN
*   end pin-mapping
.subckt TLV75533PDRVR OUT NC1 GND EN NC2 IN
  MSW  IN  VGEN VSW VSW MOSEN
  MCL VSW VCL VCL VCL MOSCL
  MREG VCL  GND   OUT   OUT  MOSREG
  M4 VNEN  EN  VUVLO VUVLO MOSLOGN
  M7 VUVLO  IN   GND   GND  MOSUVLO
  M6 VFEN VNEN  GND   GND  MOSLOGN
  M5 VFEN VNEN  IN   IN  MOSLOGP
  D1  OUT   IN  SUBSTRATE
  C2 VCL  GND  1000p
  C3 VNEN  GND  100f
  C5 VGEN  GND  20p
  C6 VUVLO  GND  100f
  C7 VSW  GND  100p
  R2  IN  VNEN 1MEG
  R3 VFEN VGEN 10MEG
  CCL VCL  GND  1n
  .model MOSREG  NMOS LEVEL=1 RD=1e-3 RS=1e-3 VTO=-3.3   KP=1000
  .model MOSCL   NMOS LEVEL=1 RD=1e-3 RS=1e-3 VTO=-75e-3 KP=256
  .model MOSEN   NMOS LEVEL=1 RD=1e-3 RS=1e-3 VTO=25e-3  KP=1000
  .model MOSLOGN NMOS LEVEL=1 RD=10   RS=10   VTO=0.8    KP=1000u
  .model MOSLOGP PMOS LEVEL=1 RD=10   RS=10   VTO=-0.3   KP=200u
  .model MOSUVLO NMOS LEVEL=1 RD=10   RS=10   VTO=1.3    KP=500u
  .model SUBSTRATE D RS=0.01 N=1.5
.ends
* end model
* begin model Package_DFN_QFN:UDFN-6-1EP_2.1x2.1mm_P0.8mm:
*   begin metadata:
*     description: 7-pin WSON EP package
*     manufacturer: UNKNOWN
*     mpn: TLV73312PDRVR
*   end metadata
*   begin pin-mapping:
*     OUT: OUT
*     NC1: NC1
*     GND: GND
*     EN: EN
*     NC2: NC2
*     IN: IN
*   end pin-mapping
.subckt TLV73312PDRVR OUT NC1 GND EN NC2 IN
  M1  IN  N001 VSW VSW mosen
  M2 VSW VCL VCL VCL moscl
  M3 VCL  GND   OUT   OUT  mosreg
  C2 N003  GND  100pF
  M4 VNEN  EN   GND   GND  moslogn
  C3 VNEN  GND  100fF
  C5 N001  GND  1.5pF
  R2  IN  VNEN 1Meg
  M7 VUVLO  IN   GND   GND  mosuvlo
  C6 VUVLO  GND  100fF
  C7 N002  GND  100pF
  D1  OUT   IN  substrate
  R5  IN  VUVLO 1Meg
  M11 VNUVLO VUVLO  IN   IN  moslogp
  M12 VNUVLO VUVLO  GND   GND  moslogn
  M5 VFEN VNEN  IN   IN  moslogp
  M6 VFEN VNEN  GND   GND  moslogn
  M9 N005 VNUVLO  GND   GND  moslogn
  M10 N004 VFEN N005 N005 moslogn
  M13 N004 VNUVLO  IN   IN  moslogp
  M14 N004 VFEN  IN   IN  moslogp
  M15 VFEN N001 N001 N001 softstart
  C8 VNUVLO  GND  2pF
  C9 VFEN  GND  2pF
  C10 N004  GND  100pF
  D2  EN   IN  inpprotect
  D3  GND   EN  inpprotect
  D4  GND   OUT  outprotect
  R3  IN   EN  10Meg
  R6 VENS  EN  50
  M16 N003 N004  GND   GND  mosacti
  R7 VCL N003 240
  M17 N002 N004  GND   GND  mosacti
  R8 VSW N002 240
  .model mosreg NMOS LEVEL=1 RD=200m RS=10m VTO=-1.2 KP=1000
  .model moscl NMOS LEVEL=1 RD=200m RS=10m VTO=-75m KP=180
  .model mosen NMOS LEVEL=1 RD=200m RS=10m VTO=25m KP=1000
  .model moslogn NMOS LEVEL=1 RD=40 RS=40 VTO=0.8 KP=100u
  .model moslogp PMOS LEVEL=1 RD=40 RS=40 VTO=-0.3 KP=20u
  .model mosuvlo NMOS LEVEL=1 RD=10 RS=10 VTO=1.3 KP=50u
  .model substrate D RS=.01 N=1.5
  .model inpprotect D RS=1 N=1 IS=1e-6
  .model outprotect D RS=0.1 N=1 BV=3.6 IBV=10u
  .model softstart NMOS LEVEL=1 RD=10 RS=10 VTO=-75m KP=2u
  .model mosacto NMOS LEVEL=1 RD=119 RS=1 VTO=25m KP=100
  .model mosacti NMOS LEVEL=1 RD=4 RS=1 VTO=25m KP=1
.ends
* end model
* begin model Connector_USB:USB_Micro-B_Molex_47346-0001:
*   begin metadata:
*     description: Micro USB B receptable with flange, bottom-mount, SMD, right-angle (http://www.molex.com/pdm_docs/sd/473460001_sd.pdf
*     manufacturer: UNKNOWN
*     mpn: UNKNOWN
*   end metadata
*   begin pin-mapping:
*     p[1]: p1
*     p[2]: p2
*     p[3]: p3
*     p[4]: p4
*     p[5]: p5
*     p[6]: p6
*   end pin-mapping
.subckt Connector_USB:USB_Micro_B_Molex_47346_0001 p1 p2 p3 p4 p5 p6
  V1  p1   p5  EXP(0 5 200u 200u 20 20)
  RPU  p3   p1  50
  RDK  p2   p5  50
  RRSH  p5   p6  1
  RNC1  p4   p5  100MEG
.ends
* end model
* begin model Package_TO_SOT_SMD:SOT-23-6:
*   begin metadata:
*     description: 6-pin SOT-23 package
*     manufacturer: UNKNOWN
*     mpn: LM3880
*   end metadata
*   begin pin-mapping:
*     VCC: VCC
*     GND: GND
*     EN: EN
*     FLAG1: FLAG1
*     FLAG2: FLAG2
*     FLAG3: FLAG3
*   end pin-mapping
.subckt LM3880 VCC GND EN FLAG1 FLAG2 FLAG3
  M1 VNI  EN  VSDP VSDP MDIFF
  M2 VNP VZREF VSDP VSDP MDIFF
  D1  GND  VZREF DZREF
  M3 VNI VNI  VCC   VCC  MPMIR
  M4 VNP VNP  VCC   VCC  MPMIR
  M5 ENA VNI  VCC   VCC  MPGAIN
  M6 ENB VNP  VCC   VCC  MPGAIN
  M7 VSDP  GND   GND   GND  MDISRC
  M8 ENA VSG VSG VSG MDISRC
  M9 ENB VSG VSG VSG MDISRC
  M10  VCC  VZREF VZREF VZREF MDISRC
  R1  VCC   EN  24.3K
  M11 VSG  GND   GND   GND  MDIGAIN
  M12 VCMP ENB  VCC   VCC  MOSLOGP
  M13 VCMP ENB  GND   GND  MOSLOGN
  M14  VCC   EN   EN   EN  MPPU
  C1  EN   GND  7pF
  C2 VZREF  GND  4pF
  C3 ENB  GND  1.3pF
  C4 VNP  GND  2.5pF
  C5 VNI  GND  2.5pF
  C6 ENA  GND  1.3pF
  M15 VCMP  GND  VRGO VRGO MVREG
  C7 VCMP  GND  7pF
  C8 VRGO  GND  7pF
  C9 VRAMP N003 5nF
  D2 VRGI VRAMP DRAMP
  M16 VDRMP VCMP VCMP VCMP MIRAMP
  M17 VRGO VRGI VRGI VRGI MIRAMP
  D3 VRAMP VDRMP DRAMP
  C10 VDRMP VCMP 7pF
  C11 VRGI VRGO 7pF
  M18 VNIA VRAMP VSDPA VSDPA MDIFF
  M19 VNPA VZREFA VSDPA VSDPA MDIFF
  D4  GND  VZREFA DZREFA
  M20 VNIA VNIA  VCC   VCC  MPMIR
  M21 VNPA VNPA  VCC   VCC  MPMIR
  M22 ENAA VNPA  VCC   VCC  MPGAIN
  M23 ENBA VNIA  VCC   VCC  MPGAIN
  M24 VSDPA  GND   GND   GND  MDISRC
  M25 ENAA VSGA VSGA VSGA MDISRC
  M26 ENBA VSGA VSGA VSGA MDISRC
  M27  VCC  VZREFA VZREFA VZREFA MDISRC
  M28 VSGA  GND   GND   GND  MDIGAIN
  M29  FLAG3  ENAA  VCC   VCC  MOSFLAGP
  M30  FLAG3  ENAA  GND   GND  MOSFLAGN
  C13 VZREFA  GND  4pF
  C14 ENAA  GND  1.3pF
  C15 VNIA  GND  2.5pF
  C16 VNPA  GND  2.5pF
  C17 ENBA  GND  1.3pF
  C18  FLAG3   GND  7pF
  M31 VNIB VRAMP VSDPB VSDPB MDIFF
  M32 VNPB VZREFB VSDPB VSDPB MDIFF
  D5  GND  VZREFB DZREFB
  M33 VNIB VNIB  VCC   VCC  MPMIR
  M34 VNPB VNPB  VCC   VCC  MPMIR
  M35 ENBB VNPB  VCC   VCC  MPGAIN
  M36 ENAB VNIB  VCC   VCC  MPGAIN
  M37 VSDPB  GND   GND   GND  MDISRC
  M38 ENBB VSGB VSGB VSGB MDISRC
  M39 ENAB VSGB VSGB VSGB MDISRC
  M40  VCC  VZREFB VZREFB VZREFB MDISRC
  M41 VSGB  GND   GND   GND  MDIGAIN
  M42  FLAG2  ENBB  VCC   VCC  MOSFLAGP
  M43  FLAG2  ENBB  GND   GND  MOSFLAGN
  C12 VZREFB  GND  4pF
  C19 ENBB  GND  1.3pF
  C20 VNIB  GND  2.5pF
  C21 VNPB  GND  2.5pF
  C22 ENAB  GND  1.3pF
  C23  FLAG2   GND  7pF
  M44 VNIC VRAMP VSDPC VSDPC MDIFF
  M45 VNPC VZREFC VSDPC VSDPC MDIFF
  D6  GND  VZREFC DZREFC
  M46 VNIC VNIC  VCC   VCC  MPMIR
  M47 VNPC VNPC  VCC   VCC  MPMIR
  M48 ENAC VNPC  VCC   VCC  MPGAIN
  M49 N001 VNIC  VCC   VCC  MPGAIN
  M50 VSDPC  GND   GND   GND  MDISRC
  M51 ENAC VSGC VSGC VSGC MDISRC
  M52 N001 VSGC VSGC VSGC MDISRC
  M53  VCC  VZREFC VZREFC VZREFC MDISRC
  M54 VSGC  GND   GND   GND  MDIGAIN
  M55  FLAG1  ENAC  VCC   VCC  MOSFLAGP
  M56  FLAG1  ENAC  GND   GND  MOSFLAGN
  C24 VZREFC  GND  4pF
  C25 ENAC  GND  1.3pF
  C26 VNIC  GND  2.5pF
  C27 VNPC  GND  2.5pF
  C28 N001  GND  1.3pF
  C29  FLAG1   GND  7pF
  D7  GND   EN  DESD
  D8  EN   VCC  DESD
  D9 N003 VRAMP DZRAMP
  M57  GND   GND  N003 N003 MPVN
  C30 N003  GND  200pF
  M59  VCC  N003 N003 N003 MDISRC
  .model MDIFF NMOS LEVEL=1 RD=10 RS=10 VTO=-0.35 KP=100u
  .model MDISRC NMOS LEVEL=1 RD=10 RS=10 VTO=-0.35 KP=65.3u
  .model MPMIR PMOS LEVEL=1 RD=10 RS=10 VTO=.35 KP=40u
  .model MPGAIN PMOS LEVEL=1 RD=10 RS=10 VTO=0.15 KP=110u
  .model MDIGAIN NMOS LEVEL=1 RD=10 RS=10 VTO=-0.35 KP=200u
  .model MPPU NMOS LEVEL=1 RD=10 RS=10 VTO=-0.8 KP=21.875u
  .model MOSLOGN NMOS LEVEL=1 RD=10 RS=10 VTO=0.8 KP=100u
  .model MOSLOGP PMOS LEVEL=1 RD=10 RS=10 VTO=-0.3 KP=20u
  .model MOSFLAGN NMOS LEVEL=1 RD=1 RS=1 VTO=0.8 KP=2.2m
  .model MOSFLAGP PMOS LEVEL=1 RD=1 RS=1 VTO=-0.3 KP=440u
  .model DZREF D RS=0.1 N=1 BV=1.25 IBV=4u
  .model DZREFA D RS=0.1 N=1 BV=1.4 IBV=4u
  .model DZREFB D RS=0.1 N=1 BV=1.1 IBV=4u
  .model DZREFC D RS=0.1 N=1 BV=0.8 IBV=4u
  .model DZRAMP D RS=0.1 N=1 BV=1.1 IBV=4u
  .model DESD D RS=0.1 N=1 IS=1e-8
  .model MVREG NMOS LEVEL=1 RD=10 RS=10 VTO=-2.2 KP=100u
  .model MPVN PMOS LEVEL=1 RD=10 RS=10 VTO=-0.5 KP=10m
  .model MIRAMP NMOS LEVEL=1 RD=10 RS=10 VTO=-0.5 KP=0.8u
  .model DRAMP D RS=1000 N=1 IS=1e-12
  .model QRAMP NPN BF=50 RE=1 RC=1 RB=10 CJE=10P
.ends
* end model
* begin model Capacitor_SMD:C_0402_1005Metric:
*   begin metadata:
*     description: Capacitor 0.1uF SMD CHIP 0402(English) 25V X5R 10% 0.5mm thick
*     manufacturer: UNKNOWN
*     mpn: UNKNOWN
*   end metadata
*   begin pin-mapping:
*     p[1]: p1
*     p[2]: p2
*   end pin-mapping
.subckt Capacitor_SMD:C_0402_1005Metric p1 p2
  C13   p1   p2   1.0e-07
.ends
* end model
* begin model gen-res-cmp$26:
*   begin metadata:
*     description:
*     manufacturer: UNKNOWN
*     mpn: UNKNOWN
*   end metadata
*   begin pin-mapping:
*     p[1]: p1
*     p[2]: p2
*   end pin-mapping
.subckt gen_res_cmp_26 p1 p2
  R88984   p1   p2   24300.0
.ends
* end model
* begin model Capacitor_SMD:C_0402_1005Metric:
*   begin metadata:
*     description: Capacitor 0.1uF SMD CHIP 0402(English) 25V X5R 10% 0.5mm thick
*     manufacturer: UNKNOWN
*     mpn: UNKNOWN
*   end metadata
*   begin pin-mapping:
*     p[1]: p1
*     p[2]: p2
*   end pin-mapping
.subckt Capacitor_SMD:C_0402_1005Metric p1 p2
  C8   p1   p2   1.0e-07
.ends
* end model
* begin model gen-res-cmp$28:
*   begin metadata:
*     description:
*     manufacturer: UNKNOWN
*     mpn: UNKNOWN
*   end metadata
*   begin pin-mapping:
*     p[1]: p1
*     p[2]: p2
*   end pin-mapping
.subckt gen_res_cmp_28 p1 p2
  R88985   p1   p2   10000.0
.ends
* end model
* begin model Capacitor_SMD:C_0402_1005Metric:
*   begin metadata:
*     description: Capacitor 0.1uF SMD CHIP 0402(English) 25V X5R 10% 0.5mm thick
*     manufacturer: UNKNOWN
*     mpn: UNKNOWN
*   end metadata
*   begin pin-mapping:
*     p[1]: p1
*     p[2]: p2
*   end pin-mapping
.subckt Capacitor_SMD:C_0402_1005Metric p1 p2
  C26   p1   p2   4.7e-06
.ends
* end model
* begin model gen-res-cmp$29:
*   begin metadata:
*     description:
*     manufacturer: UNKNOWN
*     mpn: UNKNOWN
*   end metadata
*   begin pin-mapping:
*     p[1]: p1
*     p[2]: p2
*   end pin-mapping
.subckt gen_res_cmp_29 p1 p2
  R88986   p1   p2   100000.0
.ends
* end model
* begin model Capacitor_SMD:C_0402_1005Metric:
*   begin metadata:
*     description: Capacitor 0.1uF SMD CHIP 0402(English) 25V X5R 10% 0.5mm thick
*     manufacturer: UNKNOWN
*     mpn: UNKNOWN
*   end metadata
*   begin pin-mapping:
*     p[1]: p1
*     p[2]: p2
*   end pin-mapping
.subckt Capacitor_SMD:C_0402_1005Metric p1 p2
  C28   p1   p2   4.7e-06
.ends
* end model
X88839 VUSB USB_N USB_P USB_NC 0 SHLD Connector_USB:USB_Micro_B_Molex_47346_0001 ; J1
X88840 SHLD 0 Capacitor_SMD:C_0402_1005Metric ; C13
X88841 VUSB 0 Capacitor_SMD:C_0402_1005Metric ; C8
X88842 P5V 0 Capacitor_SMD:C_0402_1005Metric ; C26
X88843 P3R3V 0 Capacitor_SMD:C_0402_1005Metric ; C28
X88844 VUSB 0 VUSB P5V USB_N USB_P TPD3S014DBVR ; U15
X88845 P3R3V P3R3V 0 P3V3EN P5V P5V TLV75533PDRVR ; U8
X88846 P5V 0 Capacitor_SMD:C_0402_1005Metric ; C86
X88847 P1R2V 0 Capacitor_SMD:C_0402_1005Metric ; C27
X88848 P1R2V P1R2V 0 P1V2EN P5V P5V TLV73312PDRVR ; U36
X88849 P5V 0 PGOOD P1V2EN P3V3EN 88983 LM3880 ; U7
X88850 P5V PGOOD gen_res_cmp_26 ; R5
X88851 PGOOD 0 gen_res_cmp_28 ; R6
X88852 P5V P3V3EN gen_res_cmp_29 ; R7
X88853 P5V P1V2EN gen_res_cmp_29 ; R8

.options savecurrents
.save all
.op
.end
