* /Users/toma/Documents/jitx/glasgow-simulation/model_lib/models/LM3880/ltspice/LM3880.asc
M1 VNI EN VSDP VSDP MDIFF
M2 VNP VZREF VSDP VSDP MDIFF
D1 0 VZREF DZREF
M3 VNI VNI VCC VCC MPMIR
M4 VNP VNP VCC VCC MPMIR
M5 ENA VNI VCC VCC MPGAIN
M6 ENB VNP VCC VCC MPGAIN
M7 VSDP 0 0 0 MDISRC
M8 ENA VSG VSG VSG MDISRC
M9 ENB VSG VSG VSG MDISRC
V1 VCC 0 PWL(0 0 100u 0 500u 5)
M10 VCC VZREF VZREF VZREF MDISRC
R1 VCC EN 24.3K
R2 EN 0 10K
M11 VSG 0 0 0 MDIGAIN
V2 EN 0 PWL(0 0 100u 0 500u 1.15 1.5m 1.35 2m 5 3m 5 3.001m 0 10m 0 10.001m 3 160m 3 160.001m 0 240m 0 240.001m 3)
M12 VCMP ENB VCC VCC MOSLOGP
M13 VCMP ENB 0 0 MOSLOGN
M14 VCC EN EN EN MPPU
C1 EN 0 7pF
C2 VZREF 0 4pF
C3 ENB 0 1.3pF
C4 VNP 0 2.5pF
C5 VNI 0 2.5pF
C6 ENA 0 1.3pF
M15 VCMP 0 VRGO VRGO MVREG
C7 VCMP 0 7pF
C8 VRGO 0 7pF
C9 VRAMP N003 5nF
D2 VRGI VRAMP DRAMP
M16 VDRMP VCMP VCMP VCMP MIRAMP
M17 VRGO VRGI VRGI VRGI MIRAMP
D3 VRAMP VDRMP DRAMP
C10 VDRMP VCMP 7pF
C11 VRGI VRGO 7pF
M18 VNIA VRAMP VSDPA VSDPA MDIFF
M19 VNPA VZREFA VSDPA VSDPA MDIFF
D4 0 VZREFA DZREFA
M20 VNIA VNIA VCC VCC MPMIR
M21 VNPA VNPA VCC VCC MPMIR
M22 ENAA VNPA VCC VCC MPGAIN
M23 ENBA VNIA VCC VCC MPGAIN
M24 VSDPA 0 0 0 MDISRC
M25 ENAA VSGA VSGA VSGA MDISRC
M26 ENBA VSGA VSGA VSGA MDISRC
M27 VCC VZREFA VZREFA VZREFA MDISRC
M28 VSGA 0 0 0 MDIGAIN
M29 VCMPA ENAA VCC VCC MOSFLAGP
M30 VCMPA ENAA 0 0 MOSFLAGN
C13 VZREFA 0 4pF
C14 ENAA 0 1.3pF
C15 VNIA 0 2.5pF
C16 VNPA 0 2.5pF
C17 ENBA 0 1.3pF
C18 VCMPA 0 7pF
M31 VNIB VRAMP VSDPB VSDPB MDIFF
M32 VNPB VZREFB VSDPB VSDPB MDIFF
D5 0 VZREFB DZREFB
M33 VNIB VNIB VCC VCC MPMIR
M34 VNPB VNPB VCC VCC MPMIR
M35 ENBB VNPB VCC VCC MPGAIN
M36 ENAB VNIB VCC VCC MPGAIN
M37 VSDPB 0 0 0 MDISRC
M38 ENBB VSGB VSGB VSGB MDISRC
M39 ENAB VSGB VSGB VSGB MDISRC
M40 VCC VZREFB VZREFB VZREFB MDISRC
M41 VSGB 0 0 0 MDIGAIN
M42 VCMPB ENBB VCC VCC MOSFLAGP
M43 VCMPB ENBB 0 0 MOSFLAGN
C12 VZREFB 0 4pF
C19 ENBB 0 1.3pF
C20 VNIB 0 2.5pF
C21 VNPB 0 2.5pF
C22 ENAB 0 1.3pF
C23 VCMPB 0 7pF
M44 VNIC VRAMP VSDPC VSDPC MDIFF
M45 VNPC VZREFC VSDPC VSDPC MDIFF
D6 0 VZREFC DZREFC
M46 VNIC VNIC VCC VCC MPMIR
M47 VNPC VNPC VCC VCC MPMIR
M48 ENAC VNPC VCC VCC MPGAIN
M49 N001 VNIC VCC VCC MPGAIN
M50 VSDPC 0 0 0 MDISRC
M51 ENAC VSGC VSGC VSGC MDISRC
M52 N001 VSGC VSGC VSGC MDISRC
M53 VCC VZREFC VZREFC VZREFC MDISRC
M54 VSGC 0 0 0 MDIGAIN
M55 VCMPC ENAC VCC VCC MOSFLAGP
M56 VCMPC ENAC 0 0 MOSFLAGN
C24 VZREFC 0 4pF
C25 ENAC 0 1.3pF
C26 VNIC 0 2.5pF
C27 VNPC 0 2.5pF
C28 N001 0 1.3pF
C29 VCMPC 0 7pF
D7 0 EN DESD
D8 EN VCC DESD
D9 N003 VRAMP DZRAMP
M57 0 0 N003 N003 MPVN
C30 N003 0 200pF
M59 VCC N003 N003 N003 MDISRC
.model D D
.lib /Users/toma/Library/Application Support/LTspice/lib/cmp/standard.dio
.model NMOS NMOS
.model PMOS PMOS
.lib /Users/toma/Library/Application Support/LTspice/lib/cmp/standard.mos
.tran 1u 320m
.model MDIFF VDMOS(RD=10 RS=10 VTO=-0.35 KP=100u)
.model MDISRC VDMOS(RD=10 RS=10 VTO=-0.35 KP=65.3u)
.model MPMIR VDMOS(pchan RD=10 RS=10 VTO=.35 KP=40u)
.model MPGAIN VDMOS(pchan RD=10 RS=10 VTO=0.15 KP=110u)
.model MDIGAIN VDMOS(RD=10 RS=10 VTO=-0.35 KP=200u)
.model MPPU VDMOS(RD=10 RS=10 VTO=-0.8 KP=21.875u)
.model MOSLOGN VDMOS(RD=10 RS=10 VTO=0.8 KP=100u)
.model MOSLOGP VDMOS(pchan RD=10 RS=10 VTO=-0.3 KP=20u)
.model MOSFLAGN VDMOS(RD=1 RS=1 VTO=0.8 KP=2.2m)
.model MOSFLAGP VDMOS(pchan RD=1 RS=1 VTO=-0.3 KP=440u)
.model DZREF D RS=0.1 N=1 BV=1.25 IBV=4u
.model DZREFA D RS=0.1 N=1 BV=1.4 IBV=4u
.model DZREFB D RS=0.1 N=1 BV=1.1 IBV=4u
.model DZREFC D RS=0.1 N=1 BV=0.8 IBV=4u
.model DZRAMP D RS=0.1 N=1 BV=1.1 IBV=4u
.model DESD D RS=0.1 N=1 IS=1e-8
.model MVREG VDMOS(RD=10 RS=10 VTO=-2.2 KP=100u
.model MPVN VDMOS(pchan RD=10 RS=10 VTO=-0.5 KP=10m)
.model MIRAMP VDMOS(RD=10 RS=10 VTO=-0.5 KP=0.8u)
.model DRAMP D RS=1000 N=1 IS=1e-12
.model QRAMP NPN BF=50 RE=1 RC=1 RB=10 CJE=10P
.backanno
.end
